V1 1 0 Symbolic
O1 2 0 3
R4 2 4 Symbolic
R3 4 3 Symbolic
C2 5 3 Symbolic
C4 2 5 Symbolic
C3 0 4 Symbolic
R5 3 2 Symbolic
R1 5 1 Symbolic
R2 4 1 Symbolic
C1 5 1 Symbolic
